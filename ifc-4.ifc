Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler, steckfertig, 5…30 °C, 230 VAC, 13 (4) A, 1,5 m Kabel, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA013200, Raumtemperaturregler, steckfertig, 5…30 °C, 230 VAC, 13 (4) A, 1,5 m Kabel
In: Raum
Description: Elektromechanischer Raumtemperaturregler für Radiatoren, Heizkamine, Elektrodirektheizungen, Marmorheizungen, Natursteinheizungen usw.. Mittels der sich unter dem Knopf befindlichen Einstellfahnen kann der Temperatur-Einstellbereich mechanisch begrenzt werden. Die Länge des Anschlusskabels beträgt 1,5 m. Mit vormontiertem Schutzkontakt-Stecksockel JZ-19 am Regler und Kabel mit Schutzkontakt-Kupplung.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA013200; ModelLabel: RTBSB-001.411; GlobalTradeItemNumber: 4050528049841; ProductURL: https://alre.de/produkt_MA013200
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0445 m; NetWeight: 0.39
Pset_ALRE_ETIM_Properties - Montageart: sonstige; Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 44.5; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Öffner (NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Temperatur ablesbar: no; Max. Kontaktbelastung: 13; Differenzwert: 1; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA013200.pdf
